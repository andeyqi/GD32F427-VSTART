# IAR project Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F427xK GD GD32F427xK
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F427
  ICCARM.CCIncludePath2: ..; ..\..\..\..\GD32F4xx_Firmware_Library\GD32F4xx_standard_peripheral\Include; ..\..\..\..\GD32F4xx_Firmware_Library\CMSIS; ..\..\..\..\GD32F4xx_Firmware_Library\CMSIS\GD\GD32F4xx\Include; ..\..\..\..\GD32F4xx_Firmware_Library\CMSIS\GD; ..\..\..\Utilities; ..\littleshell; ..\FreeRTOSv10.3.1; ..\FreeRTOSv10.3.1\Source\include; ..\FreeRTOSv10.3.1\Source\portable\IAR\ARM_CM4F; ..; ..\common; ..\driver
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\FreeRTOSv10.3.1
  OBJCOPY.OOCOutputFile: Project.srec
  postbuild: ..\tools\ImageCRC.bat   $TARGET_BPATH$
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: ..\linkfile\GD32F427xK.icf
  ILINK.IlinkExtraOptions: --keep __checksum; --place_holder __checksum,4,.checksum,4
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    ../: gd32f4xx_it.c main.c systick.c
  group asmtest
    ../asm_test/: asm_test.s asm_test_cmd.c
  group CMSIS
    ../../../../GD32F4xx_Firmware_Library/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group common
    ../common/: crc32.c ringbuffer.c utilities.c
  group Doc
    ../: readme.txt
  group driver
    ../driver/: uart.c
  group freertos
    ../FreeRTOSv10.3.1/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FreeRTOSv10.3.1/Source/portable/MemMang/: heap_4.c
    ../FreeRTOSv10.3.1/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group GD32F4xx_Peripherals
    ../../../../GD32F4xx_Firmware_Library/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group GD32F4xx_START
    ../../../Utilities/: gd32f427v_start.c
  group shell
    ../littleshell/: littleshell.c
  group Startup
    ../../../../GD32F4xx_Firmware_Library/CMSIS/GD/GD32F4xx/Source/IAR/: startup_gd32f407_427.s
  group test
    ../test/: test_crc.c test_led.c test_misc.c
