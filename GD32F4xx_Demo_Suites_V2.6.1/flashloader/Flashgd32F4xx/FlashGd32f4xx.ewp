# IAR project FlashGd32f4xx.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCIncludePath2: src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: FlashGd32f4xx.out
  ILINK.IlinkIcfFile: linkfile\FlashGD32F4xxx_96kB.icf
  ILINK.IlinkProgramEntryLabel: FlashInitEntry
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    src/: Flash_GD32f4xxx.c
  group framework
    framework2/: flash_loader.c flash_loader_asm.s
